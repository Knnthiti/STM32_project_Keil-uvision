# Keil uVision project ADC_oversampling.uvprojx, settings and files
target STM32G474 (6240000::V6.24::ARMCLANG)
  device: STM32G474RETx STMicroelectronics
  pack: Keil.STM32G4xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 DSP CLOCK(12000000) ELITTLE
  output: ADC_oversampling
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_FULL_LL_DRIVER
  c include: ..\libraries\CMSIS\Device\ST\STM32G4xx\Include;..\libraries\CMSIS\Device\ST\STM32G4xx\Source;..\libraries\STM32G4xx_HAL_Driver\Inc;..\libraries\STM32G4xx_HAL_Driver\Src;..\BPS\Inc;..\BPS\Src;..\App\Inc;..\App\Src;..\libraries\CMSIS\Core\Include
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group StartUP
    ../libraries/CMSIS/Device/ST/STM32G4xx/Source/Templates/arm/: startup_stm32g474xx.s
    ../libraries/CMSIS/Device/ST/STM32G4xx/Source/Templates/: system_stm32g4xx.c
    ../libraries/CMSIS/Device/ST/STM32G4xx/Include/: stm32g4xx.h system_stm32g4xx.h stm32g474xx.h
    ../libraries/CMSIS/Core/Include/: core_cm4.h
  group LL_driver
    ../libraries/STM32G4xx_HAL_Driver/Inc/: stm32g4xx_ll_adc.h stm32g4xx_ll_bus.h stm32g4xx_ll_gpio.h stm32g4xx_ll_pwr.h stm32g4xx_ll_rcc.h stm32g4xx_ll_system.h stm32g4xx_ll_utils.h stm32g4xx_ll_dma.h stm32g4xx_ll_tim.h
    ../libraries/STM32G4xx_HAL_Driver/Src/: stm32g4xx_ll_adc.c stm32g4xx_ll_dma.c stm32g4xx_ll_gpio.c stm32g4xx_ll_pwr.c stm32g4xx_ll_rcc.c stm32g4xx_ll_utils.c stm32g4xx_ll_tim.c
  group BPS
    ../BPS/Inc/: ADC.h TIM.h Clock_system.h
    ../BPS/Src/: ADC.c TIM.c Clock_system.c
  group App
    ../App/Inc/: main.h
    ../App/Src/: main.c
