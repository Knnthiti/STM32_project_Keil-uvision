# Keil uVision project SPI.uvprojx, settings and files
target STM32G474RET (6240000::V6.24::ARMCLANG)
  device: STM32G474RETx STMicroelectronics
  pack: Keil.STM32G4xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 DSP CLOCK(12000000) ELITTLE
  output: SPI
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_FULL_LL_DRIVER
  c include: ..\libraries\CMSIS\Core\Include;..\libraries\CMSIS\Device\ST\STM32G4xx\Include;..\libraries\CMSIS\Device\ST\STM32G4xx\Source\Templates;..\libraries\CMSIS\Device\ST\STM32G4xx\Source\Templates\arm;..\libraries\STM32G4xx_HAL_Driver\Inc;..\libraries\STM32G4xx_HAL_Driver\Src;..\BPS\Inc;..\BPS\Src;..\App\Inc;..\App\Src
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group StartUP
    ../libraries/CMSIS/Core/Include/: core_cm4.h
    ../libraries/CMSIS/Device/ST/STM32G4xx/Include/: stm32g4xx.h stm32g474xx.h system_stm32g4xx.h
    ../libraries/CMSIS/Device/ST/STM32G4xx/Source/Templates/: system_stm32g4xx.c
    ../libraries/CMSIS/Device/ST/STM32G4xx/Source/Templates/arm/: startup_stm32g474xx.s
  group STM32G474_LL_Driver
    ../libraries/STM32G4xx_HAL_Driver/Inc/: stm32g4xx_ll_adc.h stm32g4xx_ll_bus.h stm32g4xx_ll_dma.h stm32g4xx_ll_dmamux.h stm32g4xx_ll_gpio.h stm32g4xx_ll_pwr.h stm32g4xx_ll_rcc.h stm32g4xx_ll_spi.h stm32g4xx_ll_system.h stm32g4xx_ll_tim.h stm32g4xx_ll_usart.h stm32g4xx_ll_utils.h
    ../libraries/STM32G4xx_HAL_Driver/Src/: stm32g4xx_ll_adc.c stm32g4xx_ll_dma.c stm32g4xx_ll_gpio.c stm32g4xx_ll_pwr.c stm32g4xx_ll_rcc.c stm32g4xx_ll_spi.c stm32g4xx_ll_tim.c stm32g4xx_ll_usart.c stm32g4xx_ll_utils.c
  group BPS
    ../BPS/Inc/: Clock_system.h SPI.h
    ../BPS/Src/: Clock_system.c SPI.c
  group App
    ../App/Inc/: main.h
    ../App/Src/: main.c
